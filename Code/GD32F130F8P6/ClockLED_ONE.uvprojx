# Keil uVision project ClockLED_ONE.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F130F8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ClockLED_ONE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150,DEBUG
  c misc: --diag_suppress=188,177,870
  c include: .\Firmware\CMSIS\GD\GD32F1x0\Include;.\Firmware\GD32F1x0_standard_peripheral\Include;.\Firmware\CMSIS;.\Inc;.\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Src/: main.c gd32f1x0_it.c systick.c tm1637.c debug_printf.c delay.c encoder.c ds18b20.c ds1302.c menus.c flash.c buzzer.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ./Firmware/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Peripherals
    ./Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c gd32f1x0_misc.c gd32f1x0_dbg.c gd32f1x0_fmc.c
  group Utilities
    ./Utilities/: gd32f1x0r_eval.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F130F8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: as above
  output: ClockLED_ONE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
